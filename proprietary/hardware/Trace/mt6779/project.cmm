global &project
&project="k3967_64"
